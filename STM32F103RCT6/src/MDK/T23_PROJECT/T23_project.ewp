# IAR project T23_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __ICCARM__; IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa082, Pa093, pe111, pe177, pe550, pe127,pe188
  ICCARM.CCIncludePath2: ..\App\inc; ..\BSP\inc; ..\Drivers\inc; ..\IAP\inc; ..\Virtual_COM_Port\inc; ..\..\Library\CMSIS\Core\CM3; ..\..\Library\CMSIS\Core\CM3\startup\iar; ..\..\Library\STM32F10x_StdPeriph_Driver\inc; ..\..\Library\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\OS\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\BSP\inc
  OBJCOPY.OOCOutputFile: T23_project.bin
  ILINK.IlinkOutputFile: T23_project.out
  ILINK.IlinkIcfFile: D:\sop1hc\Earth2\Code\Moisture_Ctl\src\MDK\T23_PROJECT\stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group APP
    ../App/src/: Accelerometer.c ADC.c Alarm.c Battery.c blowfish.c Delayms.c EXTI_ACCE.c gps.c gsm.c langconfig.c Main.c Trip.c usbInf.c
  group BSP
    ../BSP/src/: bsp_spi.c stm32f10x_it.c
    ../../Library/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c
  group Drivers
    ../Drivers/src/: spi_flash_inf.c
  group IAP
    ../IAP/src/: common.c download.c ymodem.c
  group Library/CMSIS
    ../../Library/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../../Library/CMSIS/Core/CM3/startup/iar/: Startup_stm32f10x_hd.c
  group Library/STM32_USB-FS-Device_Driver
    ../../Library/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Library/STM32F10X_StdPeriph_Driver
    ../../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USBVirtualCom
    ../Virtual_COM_Port/src/: usb_desc.c usb_endp.c usb_hw_config.c usb_istr.c usb_prop.c usb_pwr.c
