# IAR project Backup of T23_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: __ICCARM__; IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa082, Pa093, pe111, pe177, pe550, pe127,pe188
  ICCARM.CCIncludePath2: ..\App\inc; ..\BSP\inc; ..\Drivers\inc; ..\IAP\inc; ..\Virtual_COM_Port\inc; ..\..\Library\CMSIS\Core\CM3; ..\..\Library\CMSIS\Core\CM3\startup\iar; ..\..\Library\STM32F10x_StdPeriph_Driver\inc; ..\..\Library\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: ..\OS\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\BSP\inc
  OBJCOPY.OOCOutputFile: T23_project.bin
  ILINK.IlinkOutputFile: T23_project.out
  ILINK.IlinkIcfFile: ..\BSP\inc\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group APP
    ../App/src/: Main.c usbInf.c
  group BSP
    ../BSP/src/: bsp_spi.c stm32f10x_it.c
  group Drivers
    ../Drivers/src/: spi_flash_inf.c
  group IAP
    ../IAP/src/: common.c download.c ymodem.c
  group Library/CMSIS
    ../../Library/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../../Library/CMSIS/Core/CM3/startup/iar/: Startup_stm32f10x_hd.c
  group Library/STM32_USB-FS-Device_Driver
    ../../Library/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Library/STM32F10X_StdPeriph_Driver
    ../../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USBVirtualCom
    ../Virtual_COM_Port/src/: usb_desc.c usb_endp.c usb_hw_config.c usb_istr.c usb_prop.c usb_pwr.c
